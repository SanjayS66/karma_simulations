Commit message: fixed teleop, need to fix the controllers issue

File: urdf/ArmPlate.urdf (robot description, URDF)
Before this commit: robot ArmPlate, 51 links, 50 joints
Joints:
- joint base_to_robot: origin xyz=0.0 0.35 -0.07 rpy=1.57 0.0 0.0 -> xyz=0.0 0.35 -0.07 rpy=1.57 0.0 1.57
